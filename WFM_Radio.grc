options:
  parameters:
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: Button
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,1
    label: 周波数設定
    label0: 放送局一覧
    label1: 周波数指定
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: display_freq
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: 周波数
    type: real
    value: (1-Button)*freq1+Button*freq0
  states: {}
- name: freq0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: 周波数
    start: 70e6
    step: '100000'
    stop: 90e6
    value: 80e6
    widget: dial
  states: {}
- name: freq1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,2
    label: 放送局
    labels: '["TOKYO FM", "J-WAVE", "NHK", "InterFM897", "放送大学", "bay-fm" ]'
    num_opts: '0'
    options: '[80e6, 813e5, 825e5, 897e5, 771e5, 78e6]'
    orient: Qt.QHBoxLayout
    type: real
    value: 80e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: switch
  id: variable_qtgui_toggle_switch
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: 電源ON/OFF
    position: '3'
    pressed: '0'
    released: '1'
    type: int
    value: '1'
    verticalalignment: '2'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: 音量
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: dial
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: '480000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: switch
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '50000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_KAISER
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: (1-Button)*freq1+Button*freq0
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,0,1,3
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_mute_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_mute_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
